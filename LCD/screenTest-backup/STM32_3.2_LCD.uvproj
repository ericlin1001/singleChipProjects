# Keil uVision project STM32_3.2_LCD.uvproj, settings and files
target STM32_3.2TFT (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: main +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c Lcd.c stm32f10x_it.c header.c
    ././: stm32f10x_vector.s
  group Lib
    J:/Keil/ARM/RV31/LIB/ST/: STM32F10xR.LIB
