# Keil uVision project LCD_Test.uvproj, settings and files
target 金牛综合测试实验之摄像头实验 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: LCD_Test +hex
  c flags: Optim=1
  c include: .\Source\User\Main;.\Source\CMSIS\Core\CM3;.\Source\STM32F10x_StdPeriph_Driver\inc;.\Source\User\LCD_Driver;.\Source\User\SD;.\Source\User\FAT;.\Source\User\Touch;.\Source\User\24LC02;.\Source\User\ADC;.\Source\User\M45PE16;.\Source\User\TEXT;.\Source\User\OV7670;.\Source\User\fatfs;.\Source\User\SDCARD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ./Source/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
    ./Source/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_hd.s
  group Main
    ./Source/User/Main/: main.c stm32f10x_it.c stm32f10x_conf.h USART.c
  group LCD_Driver
    ./Source/User/LCD_Driver/: ILI932x.c hz16.c bmp.c ILI932x_conf.h hz16.h
  group OV7670
    ./Source/User/OV7670/: OV7670.c SCCB.c OV7670.h SCCB.h
  group SDCARD
    ./Source/User/SDCARD/: sdcard.c
  group FATS
    ./Source/User/fatfs/: ccsbcs.c diskio.c ff.c
  group StdPeriph_Driver
    ./Source/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_flash.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_sdio.c
  group 说明
    ./Source/User/Document/: 说明.txt
