# Keil uVision project ARM-main.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F101C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ARM-main +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Source Group 1
    ./: entry.c initConfig.c main.c stm32f10x_it.c header.c flash.c led.c
  group FWLib
    J:/Keil/ARM/RV31/LIB/ST/: STM32F10xR.LIB
  group Asm
    ./: stm32f10x_vector.s
